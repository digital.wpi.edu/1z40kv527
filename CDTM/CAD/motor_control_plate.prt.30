# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 4.0 (file motor_control_plate.prt.30)

Parameters:
  METRIC = "NO"

Other parameters: PITCH, DRILL_DIAMETER, THREAD_DIAMETER, THREADS_PER_INCH