# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 4.0 (file mt-044-gussetcam.prt.2)

Parameters:
  METRIC = "NO"

Other parameters: PITCH, DRILL_DIAMETER, THREAD_DIAMETER, THREADS_PER_INCH