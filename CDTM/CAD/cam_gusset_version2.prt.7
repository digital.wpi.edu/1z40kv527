# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 4.0 (file cam_gusset_version2.prt.7)

Parameters:
  METRIC = "NO"

Other parameters: PITCH, DRILL_DIAMETER, THREAD_DIAMETER, THREADS_PER_INCH