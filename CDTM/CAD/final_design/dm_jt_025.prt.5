# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 4.0 (file dm_jt_025.prt.5)

Parameters:
  METRIC = "NO"

Other parameters: PITCH, DRILL_POINT_ANGLE, DRILL_DEPTH, DRILL_DIAMETER, THREAD_DIAMETER, THREADS_PER_INCH, THREAD_DEPTH, THREAD_LENGTH