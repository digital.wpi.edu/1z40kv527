# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 4.0 (file follower_arm_design_01.prt.15)

Parameters:
  METRIC = "NO"

Other parameters: PITCH, DRILL_DIAMETER, THREAD_DIAMETER, THREADS_PER_INCH, THREAD_DEPTH, THREAD_LENGTH, DRILL_POINT_ANGLE, DRILL_DEPTH