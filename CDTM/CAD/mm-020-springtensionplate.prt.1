# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 4.0 (file mm-020-springtensionplate.prt.1)

Parameters:
  METRIC = "NO"

Other parameters: PITCH, DRILL_DIAMETER, THREAD_DIAMETER, THREADS_PER_INCH